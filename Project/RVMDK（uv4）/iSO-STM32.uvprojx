# Keil uVision project iSO-STM32.uvprojx, settings and files
target adc（DMA） (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\adc;..\..\User\SysTick;..\..\User\TimBase;..\..\User\bme280;..\..\User\i2c_m;..\..\User\ESP8266;..\..\User\app_fifo;..\..\User\GPRS;..\..\User\NH4_sensor;..\..\User\protocol;..\..\User\Key;..\..\User\Ble;..\..\User\sys_time;..\..\User\w5500;..\..\User\NB-IOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c bsp_port.c
  group BSP_TiMbase
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/sys_time/: sys_time.c
  group BSP_SysTick
    ../../User/SysTick/: bsp_SysTick.c
  group BSP_USART
    ../../User/app_fifo/: app_fifo.c
    ../../User/usart/: bsp_usart_api.c bsp_usart.c
  group DOC
    ../../Doc/: readme.txt
  group NB-IOT
    ../../User/NB-IOT/: ATHandleFrame.c NB_IOT.c app_gsm.c
software components: CMSIS:CORE 4.1.0
